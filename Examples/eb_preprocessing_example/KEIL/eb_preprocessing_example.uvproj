# Keil uVision project eb_preprocessing_example.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: eb_mean_filtering_example
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\..\Common\Include;..\..\..\Include
  memory RVCT6: RAM 0x20040000 size 0x2000
  group Source
    ../../../Include/: edge_brain.h
    ../: eb_frequency_and_featureExtration_example.c
    ../../../Source/frequency_and_featureExtration/: eb_envolop_spectrum_f32.c
  group CMSIS Device
    ../../Common/Source/: system_ARMCM4.c
    ../../Common/Startup/ARM/: startup_ARMCM4.s
  group CMSIS DSP_Library
    ../../Common/Library/: arm_cortexM4lf_math.lib
